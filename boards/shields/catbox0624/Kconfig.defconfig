## boards/shields/catbox0624/Kconfig.defconfig
```kconfig
if SHIELD_CATBOX0624

config ZMK_KEYBOARD_NAME
    default "planck47"

endif # SHIELD_CATBOX0624
```
